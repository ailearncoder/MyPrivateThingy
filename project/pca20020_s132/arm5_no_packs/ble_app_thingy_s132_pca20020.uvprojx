# Keil uVision project ble_app_thingy_s132_pca20020.uvprojx, settings and files
target debug (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_thingy_s132 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=3 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 S132 NRF52832 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 DEBUG BSP_DEFINES_ONLY ARM_MATH_CM4 MPU9250 EMPL USE_DMP EMPL_TARGET_NRF52 HUMID_DEBUG BH1745_DEBUG TWI_DEBUG NRF_LOG_USES_RTT BLE_DFU_APP_SUPPORT NRF_DFU_SETTINGS_VERSION=1 AUDIO_EQ_DEF=3 DEBUG GLOBAL_DEBUG
  c misc: --c99
  c include: ..\config;..\..\..\sdk_components\ble\ble_advertising;..\..\..\sdk_components\ble\common;..\..\..\external\segger_rtt;..\..\..\sdk_components\drivers_nrf\common;..\..\..\sdk_components\drivers_nrf\clock;..\..\..\sdk_components\drivers_nrf\config;..\..\..\sdk_components\drivers_nrf\delay;..\..\..\sdk_components\drivers_nrf\gpiote;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\uart;..\..\..\sdk_components\libraries\button;..\..\..\sdk_components\libraries\fifo;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\libraries\trace;..\..\..\sdk_components\libraries\uart;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\softdevice\common\softdevice_handler;..\..\..\sdk_components\softdevice\s132\headers;..\..\..\sdk_components\softdevice\s132\headers\nrf52;..\..\..\sdk_components\toolchain;..\..\..\include\ble_services;..\..\..\include\drivers;..\..\..\include\board;..\..\..\include\modules;..\..\..\sdk_components\drivers_nrf\twi_master;..\..\..\sdk_components\libraries\led_softblink;..\..\..\sdk_components\libraries\low_power_pwm;..\..\..\include\macros;..\..\..\include\util;..\..\..\sdk_components\libraries\scheduler;..\..\..\sdk_components\libraries\fstorage;..\..\..\sdk_components\libraries\fds;..\..\..\sdk_components\libraries\experimental_section_vars;..\..\..\sdk_components\drivers_nrf\pwm;..\..\..\tools\sound;..\..\..\libs\eMD6\core\driver\include;..\..\..\libs\eMD6\core\driver\eMPL;..\..\..\libs\eMD6\core\mpl;..\..\..\libs\eMD6\core\mllite;..\..\..\libs\eMD6\core\eMPL-hal;..\..\..\libs\eMD6\core\driver\nRF52;..\..\..\sdk_components\libraries\log\src;..\..\..\sdk_components\libraries\log;..\..\..\sdk_components\ble\ble_services\ble_dfu;..\..\..\sdk_components\libraries\bootloader\dfu;..\..\..\sdk_components\libraries\crc32;..\..\..\sdk_components\drivers_nrf\saadc;..\..\..\include\util;..\..\..\sdk_components\drivers_nrf\pdm;..\..\..\libs\sr3_audio;..\..\..\libs\dvi_adpcm;..\..\..\libs\bv32fp-1.2;..\..\..\sdk_components\ble\ble_services\ble_bas
  asm define: BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x56000
  memory RVCT9: RAM 0x20004068 size 0xbf98
  group Thingy
    ../: main.c
    ../../../source/modules/: m_ble.c m_ble_mouse.c m_ble_flash.c m_environment.c m_environment_flash.c m_motion.c m_motion_flash.c m_ui.c m_ui_flash.c m_sound.c m_batt_meas.c
    ../../../source/util/: advertiser_beacon_timeslot.c twi_manager.c support_func.c
    ../config/: sdk_config.h thingy_config.h
    ../../../include/board/: pca20020.h
  group Thingy drivers
    ../../../source/drivers/: drv_ext_light.c drv_ccs811.c drv_gas_sensor.c drv_bh1745.c drv_color.c drv_speaker.c drv_mpu9250.c drv_motion.c drv_acc_lis3dh.c drv_pressure.c drv_lps22hb.c drv_sx1509.c drv_hts221.c drv_humidity.c drv_ext_gpio.c drv_mic.c
    ../../../source/util/: sx150x_led_drv_calc.c
  group Thingy_libraries
    ../../../libs/libmpllib_Keil_M4FP/: libmpllib.lib
    ../../../libs/eMD6/core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../../libs/eMD6/core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../../../libs/eMD6/core/eMPL-hal/: eMPL_outputs.c
    ../../../libs/eMD6/core/driver/nRF52/: log_nrf52.c
  group nRF_BLE
    ../../../sdk_components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../sdk_components/ble/ble_advertising/: ble_advertising.c
    ../../../source/ble_services/: ble_tes.c ble_tcs.c ble_uis.c ble_tms.c ble_tss.c
    ../../../sdk_components/ble/ble_services/ble_dfu/: ble_dfu.c
    ../../../sdk_components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../sdk_components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_BLE_Services
    ../../../sdk_components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../sdk_components/ble/ble_services/ble_hids/: ble_hids.c
  group nRF_Drivers
    ../../../sdk_components/drivers_nrf/common/: nrf_drv_common.c
    ../../../sdk_components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../sdk_components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../sdk_components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../../../sdk_components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../sdk_components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../sdk_components/drivers_nrf/hal/: nrf_saadc.c
    ../../../sdk_components/drivers_nrf/pdm/: nrf_drv_pdm.c
  group nRF_Libraries
    ../../../sdk_components/libraries/button/: app_button.c
    ../../../sdk_components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c app_util_platform.c sdk_mapped_flags.c
    ../../../sdk_components/libraries/scheduler/: app_scheduler.c
    ../../../sdk_components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../sdk_components/libraries/uart/: retarget.c
    ../../../sdk_components/libraries/led_softblink/: led_softblink.c
    ../../../sdk_components/libraries/low_power_pwm/: low_power_pwm.c
    ../../../sdk_components/libraries/fstorage/: fstorage.c
    ../../../sdk_components/libraries/fds/: fds.c
    ../../../sdk_components/libraries/bootloader/dfu/: nrf_dfu_settings.c
    ../../../sdk_components/libraries/crc32/: crc32.c
    ../../../source/util/: nrf_dfu_flash_buttonless.c
  group nRF_SoftDevice
    ../../../sdk_components/softdevice/common/softdevice_handler/: softdevice_handler_appsh.c softdevice_handler.c
    ../../../sdk_components/softdevice/s132/doc/: s132_nrf52_3.0.0_licence_agreement.txt
  group nRF_Log
    ../../../sdk_components/libraries/log/src/: nrf_log_frontend.c nrf_log_backend_serial.c
  group nRF_Segger_RTT
    ../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Codec: BV32FP
    ../../../libs/bv32fp-1.2/: a2lsp.c allpole.c allzero.c autocor.c bitpack.c bvplc.c cmtables.c coarptch.c decoder.c encoder.c excdec.c excquan.c fineptch.c gaindec.c gainquan.c levdur.c levelest.c lsp2a.c lspdec.c lspquan.c ptdec.c ptquan.c stblchck.c stblzlsp.c tables.c utility.c
  group Codec: ADPCM
    ../../../libs/dvi_adpcm/: dvi_adpcm.c
  group SR3_Audio
    ../../../libs/sr3_audio/: drv_audio_coder_adpcm.c drv_audio_coder_bv32fp.c drv_audio_dsp.c drv_audio_pdm.c
    ../config/: drv_audio_config.h
  group ::CMSIS
    F:/Keil_v5/ARM/PACK/ARM/CMSIS/4.5.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    RTE/Device/nRF52832_xxAA/: arm_startup_nrf52.s system_nrf52.c
target release (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: as above
  output: app_thingy_s132 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=3 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 S132 NRF52832 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 BSP_DEFINES_ONLY ARM_MATH_CM4 MPU9250 EMPL USE_DMP EMPL_TARGET_NRF52 NRF_LOG_USES_RTT BLE_DFU_APP_SUPPORT NRF_DFU_SETTINGS_VERSION=1 AUDIO_EQ_DEF=3
  c include: ..\config;..\..\..\sdk_components\ble\ble_advertising;..\..\..\sdk_components\ble\common;..\..\..\external\segger_rtt;..\..\..\sdk_components\drivers_nrf\common;..\..\..\sdk_components\drivers_nrf\clock;..\..\..\sdk_components\drivers_nrf\config;..\..\..\sdk_components\drivers_nrf\delay;..\..\..\sdk_components\drivers_nrf\gpiote;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\uart;..\..\..\sdk_components\libraries\button;..\..\..\sdk_components\libraries\fifo;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\libraries\trace;..\..\..\sdk_components\libraries\uart;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\softdevice\common\softdevice_handler;..\..\..\sdk_components\softdevice\s132\headers;..\..\..\sdk_components\softdevice\s132\headers\nrf52;..\..\..\sdk_components\toolchain;..\..\..\include\ble_services;..\..\..\include\drivers;..\..\..\include\board;..\..\..\include\modules;..\..\..\sdk_components\drivers_nrf\twi_master;..\..\..\sdk_components\libraries\led_softblink;..\..\..\sdk_components\libraries\low_power_pwm;..\..\..\include\macros;..\..\..\include\util;..\..\..\sdk_components\libraries\scheduler;..\..\..\sdk_components\libraries\fstorage;..\..\..\sdk_components\libraries\fds;..\..\..\sdk_components\libraries\experimental_section_vars;..\..\..\sdk_components\drivers_nrf\pwm;..\..\..\tools\sound;..\..\..\libs\eMD6\core\driver\include;..\..\..\libs\eMD6\core\driver\eMPL;..\..\..\libs\eMD6\core\mpl;..\..\..\libs\eMD6\core\mllite;..\..\..\libs\eMD6\core\eMPL-hal;..\..\..\libs\eMD6\core\driver\nRF52;..\..\..\sdk_components\libraries\log\src;..\..\..\sdk_components\libraries\log;..\..\..\sdk_components\ble\ble_services\ble_dfu;..\..\..\sdk_components\libraries\bootloader\dfu;..\..\..\sdk_components\libraries\crc32;..\..\..\sdk_components\drivers_nrf\saadc;..\..\..\include\util;..\..\..\libs\bv32fp-1.2;..\..\..\libs\dvi_adpcm;..\..\..\libs\sr3_audio;..\..\..\sdk_components\drivers_nrf\pdm;..\..\..\sdk_components\ble\ble_services\ble_bas;..\..\..\sdk_components\ble\peer_manager;..\..\..\sdk_components\ble\ble_services\ble_hids;..\..\..\sdk_components\ble\ble_services\ble_dis
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x56000
  memory RVCT9: RAM 0x20004068 size 0xbf98
target release_v0_8_0 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: as above
  output: app_thingy_s132_hw_v0_8_0 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=3 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 S132 NRF52832 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 BSP_DEFINES_ONLY ARM_MATH_CM4 MPU9250 EMPL USE_DMP EMPL_TARGET_NRF52 NRF_LOG_USES_RTT BLE_DFU_APP_SUPPORT NRF_DFU_SETTINGS_VERSION=1 AUDIO_EQ_DEF=3 THINGY_HW_v0_8_0
  c include: ..\config;..\..\..\sdk_components\ble\ble_advertising;..\..\..\sdk_components\ble\common;..\..\..\external\segger_rtt;..\..\..\sdk_components\drivers_nrf\common;..\..\..\sdk_components\drivers_nrf\clock;..\..\..\sdk_components\drivers_nrf\config;..\..\..\sdk_components\drivers_nrf\delay;..\..\..\sdk_components\drivers_nrf\gpiote;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\uart;..\..\..\sdk_components\libraries\button;..\..\..\sdk_components\libraries\fifo;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\libraries\trace;..\..\..\sdk_components\libraries\uart;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\softdevice\common\softdevice_handler;..\..\..\sdk_components\softdevice\s132\headers;..\..\..\sdk_components\softdevice\s132\headers\nrf52;..\..\..\sdk_components\toolchain;..\..\..\include\ble_services;..\..\..\include\drivers;..\..\..\include\board;..\..\..\include\modules;..\..\..\sdk_components\drivers_nrf\twi_master;..\..\..\sdk_components\libraries\led_softblink;..\..\..\sdk_components\libraries\low_power_pwm;..\..\..\include\macros;..\..\..\include\util;..\..\..\sdk_components\libraries\scheduler;..\..\..\sdk_components\libraries\fstorage;..\..\..\sdk_components\libraries\fds;..\..\..\sdk_components\libraries\experimental_section_vars;..\..\..\sdk_components\drivers_nrf\pwm;..\..\..\tools\sound;..\..\..\libs\eMD6\core\driver\include;..\..\..\libs\eMD6\core\driver\eMPL;..\..\..\libs\eMD6\core\mpl;..\..\..\libs\eMD6\core\mllite;..\..\..\libs\eMD6\core\eMPL-hal;..\..\..\libs\eMD6\core\driver\nRF52;..\..\..\sdk_components\libraries\log\src;..\..\..\sdk_components\libraries\log;..\..\..\sdk_components\ble\ble_services\ble_dfu;..\..\..\sdk_components\libraries\bootloader\dfu;..\..\..\sdk_components\libraries\crc32;..\..\..\sdk_components\drivers_nrf\saadc;..\..\..\include\util;..\..\..\libs\bv32fp-1.2;..\..\..\libs\dvi_adpcm;..\..\..\libs\sr3_audio;..\..\..\sdk_components\drivers_nrf\pdm;..\..\..\sdk_components\ble\ble_services\ble_bas
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x56000
  memory RVCT9: RAM 0x20004068 size 0xbf98
target release_v0_9_0 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: as above
  output: app_thingy_s132 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=3 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 S132 NRF52832 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 BSP_DEFINES_ONLY ARM_MATH_CM4 MPU9250 EMPL USE_DMP EMPL_TARGET_NRF52 NRF_LOG_USES_RTT BLE_DFU_APP_SUPPORT NRF_DFU_SETTINGS_VERSION=1 AUDIO_EQ_DEF=3 THINGY_HW_v0_9_0
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x56000
  memory RVCT9: RAM 0x20004068 size 0xbf98
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 8.5.0
